# Keil uVision project Project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\User;..\Lib\cmsis;..\Lib\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c stm32f10x_it.c
  group CMSIS
    ../Lib/cmsis/: core_cm3.c
    ../User/: system_stm32f10x.c
  group Startup
    ../Lib/startup/arm/: startup_stm32f10x_md.s
